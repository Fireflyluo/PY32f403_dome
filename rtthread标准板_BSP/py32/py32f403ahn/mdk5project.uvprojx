# Keil uVision project mdk5project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xC Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: RT_USING_ARMLIBC, __RTTHREAD__, PY32F403xD, USE_HAL_DRIVER, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c include: ..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;board;.;..\..\..\components\libc\compilers\common\include;board\CubeMX_Config\Inc;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\libraries\PY32F403_HAL\CMSIS\Device\PUYA\PY32F403\Include;..\..\..\libcpu\arm\cortex-m4;..\libraries;..\libraries\drivers\config;..\..\..\components\libc\posix\io\poll;..\libraries\CMSIS\Include;..\PY32F403_HAL\PY32F403_HAL_Driver\Inc;..\libraries\drivers;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\include;applications;..\..\..\components\libc\posix\io\epoll;..\libraries\PY32F403_HAL\PY32F403_HAL_Driver\Inc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\PY32F403_HAL\CMSIS\Device\PUYA\PY32F403\Include;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\finsh;..\..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../PY32F403_HAL/CMSIS/Device/PUYA/PY32F403/Source/Templates/arm/: startup_py32f403xx.s
    ../libraries/drivers/: drv_gpio.c drv_usart.c
    ../libraries/: drv_common.c
    board/CubeMX_Config/Src/: py32f403_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: cmd.c shell.c msh.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../PY32F403_HAL/PY32F403_HAL_Driver/Src/: py32f403_hal_pwr.c py32f403_hal_rcc.c py32f403_hal_crc.c py32f403_hal_rcc_ex.c py32f403_hal_usart.c py32f403_hal_gpio.c py32f403_hal_uart.c py32f403_hal_dma.c py32f403_hal.c py32f403_hal_pwr_ex.c py32f403_hal_cortex.c
    ../PY32F403_HAL/CMSIS/Device/PUYA/PY32F403/Source/Templates/: system_py32f403.c
