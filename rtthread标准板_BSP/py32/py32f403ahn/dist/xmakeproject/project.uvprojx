# Keil uVision project project.uvprojx, settings and files
target rt-thread (6240000::V6.24::ARMCLANG)
  device: PY32F403xC Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: RT_USING_ARMLIBC, PY32F403xD, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER
  c include: ..\..\..\..\components\finsh;..\..\libraries\HAL_Drivers\CMSIS\Include;applications;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\libcpu\arm\common;board\CubeMX_Config\Inc;..\..\libraries\drivers;..\..\libraries\PY32F403_HAL\CMSIS\Device\PUYA\PY32F403\Include;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\libc\posix\io\eventfd;..\..\libraries;.;..\..\libraries\drivers\config;..\..\..\..\include;board;..\..\PY32F403_HAL\PY32F403_HAL_Driver\Inc;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\ipc;..\..\libraries\PY32F403_HAL\PY32F403_HAL_Driver\Inc;..\..\..\..\components\drivers\include;..\..\libraries\CMSIS\Include;..\..\PY32F403_HAL\CMSIS\Device\PUYA\PY32F403\Include;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: pin.c
    ../../../../components/drivers/serial/: serial.c
  group Drivers
    ../../PY32F403_HAL/CMSIS/Device/PUYA/PY32F403/Source/Templates/arm/: startup_py32f403xx.s
    ../../libraries/drivers/: drv_gpio.c drv_usart.c
    ../../libraries/: drv_common.c
    board/CubeMX_Config/Src/: py32f403_hal_msp.c
    board/: board.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../../PY32F403_HAL/PY32F403_HAL_Driver/Src/: py32f403_hal_rcc_ex.c py32f403_hal.c py32f403_hal_gpio.c py32f403_hal_dma.c py32f403_hal_cortex.c py32f403_hal_usart.c py32f403_hal_crc.c py32f403_hal_uart.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_pwr.c
    ../../PY32F403_HAL/CMSIS/Device/PUYA/PY32F403/Source/Templates/: system_py32f403.c
