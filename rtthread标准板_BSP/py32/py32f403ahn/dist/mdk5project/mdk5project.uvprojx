# Keil uVision project mdk5project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xC Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: __STDC_LIMIT_MACROS, USE_HAL_DRIVER, RT_USING_LIBC, PY32F403xD, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: rt-thread\components\libc\posix\io\poll;rt-thread\libcpu\arm\common;libraries\HAL_Drivers\CMSIS\Include;PY32F403_HAL\CMSIS\Device\PUYA\PY32F403\Include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\io\epoll;libraries\PY32F403_HAL\PY32F403_HAL_Driver\Inc;rt-thread\components\drivers\include;applications;libraries\drivers;board;libraries\CMSIS\Include;rt-thread\include;rt-thread\components\drivers\include;PY32F403_HAL\PY32F403_HAL_Driver\Inc;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\finsh;libraries\PY32F403_HAL\CMSIS\Device\PUYA\PY32F403\Include;libraries;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;board\CubeMX_Config\Inc;libraries\drivers\config;.;rt-thread\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    PY32F403_HAL/CMSIS/Device/PUYA/PY32F403/Source/Templates/arm/: startup_py32f403xx.s
    board/CubeMX_Config/Src/: py32f403_hal_msp.c
    board/: board.c
    libraries/drivers/: drv_gpio.c drv_gpio.c drv_usart.c drv_usart.c
    libraries/: drv_common.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: msh.c cmd.c shell.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    PY32F403_HAL/CMSIS/Device/PUYA/PY32F403/Source/Templates/: system_py32f403.c system_py32f403.c
    PY32F403_HAL/PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal.c py32f403_hal_cortex.c py32f403_hal_cortex.c py32f403_hal_crc.c py32f403_hal_crc.c py32f403_hal_dma.c py32f403_hal_dma.c py32f403_hal_gpio.c py32f403_hal_gpio.c py32f403_hal_pwr.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_rcc_ex.c py32f403_hal_uart.c py32f403_hal_uart.c py32f403_hal_usart.c py32f403_hal_usart.c
