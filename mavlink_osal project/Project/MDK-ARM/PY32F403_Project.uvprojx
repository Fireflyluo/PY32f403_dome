# Keil uVision project PY32F403_Project.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PY32F403_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,PY32F403xD
  c include: ..\..\..\BSP\PY32f403_Firmware_Library\CMSIS\Include;..\..\..\BSP\PY32f403_Firmware_Library\CMSIS\Device\PUYA\PY32F403\Include;..\..\..\BSP\PY32f403_Firmware_Library\PY32F403_HAL_Driver\Inc;..\..\Application\Inc;..\..\..\BSP\py32_drivers\Inc;..\..\..\BSP;..\..\..\BSP\example\uart;..\..\..\BSP\example\gpio;..\..\..\BSP\example\osal;..\..\..\OSAL\MemMang;..\..\..\OSAL;..\..\..\OSAL\hal;..\..\Middleware\mavlink;..\..\Middleware\mavlink\common;..\..\Middleware\mavlink\minimal;..\..\Middleware\mavlink\standard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Application/Src/: main.c py32f403_hal_msp.c py32f403_it.c board.c
    ../../Application/Inc/: main.h py32f403_hal_conf.h py32f403_it.h board.h
  group app_task
    ../../Application/Src/: mav_task.c
  group example
    ../../../BSP/example/gpio/: gpio_example.c
    ../../../BSP/example/uart/: uart_polling_example.c uart_it_example.c uart_dma_example.c
    ../../../BSP/example/osal/: led_task.c osal_examplie.c
  group osal
    ../../../OSAL/: osal.c osal_event.c osal_memory.c osal_msg.c osal_timer.c
    ../../../OSAL/hal/: timer.c
  group mavlink
    ../../Middleware/mavlink/: mavlink_config.h mavlink_hal.c mavlink_hal.h
  group py32_drivers
    ../../../BSP/py32_drivers/Src/: drv_gpio.c drv_i2c.c drv_spi.c drv_tim.c drv_uart.c drv_tool.c drv_iwdg.c
    ../../../BSP/py32_drivers/Inc/: drv_gpio.h drv_i2c.h drv_spi.h drv_tim.h drv_uart.h drv_uart_config.h drv_tool.h drv_include.h
  group Library
    ../../../BSP/PY32f403_Firmware_Library/PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal_adc.c py32f403_hal_adc_ex.c py32f403_hal_canfd.c py32f403_hal_cortex.c py32f403_hal_crc.c py32f403_hal_ctc.c py32f403_hal_dma.c py32f403_hal_esmc.c py32f403_hal_exti.c py32f403_hal_flash.c py32f403_hal_gpio.c py32f403_hal_i2c.c py32f403_hal_i2s.c py32f403_hal_irda.c py32f403_hal_iwdg.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_rtc.c py32f403_hal_rtc_ex.c py32f403_hal_sd.c py32f403_hal_smartcard.c py32f403_hal_spi.c py32f403_hal_spi_ex.c py32f403_hal_tim.c py32f403_hal_tim_ex.c py32f403_hal_uart.c py32f403_hal_usart.c py32f403_hal_wwdg.c py32f403_ll_adc.c py32f403_ll_crc.c py32f403_ll_ctc.c py32f403_ll_dma.c py32f403_ll_exti.c py32f403_ll_gpio.c py32f403_ll_i2c.c py32f403_ll_pwr.c py32f403_ll_rcc.c py32f403_ll_rtc.c py32f403_ll_sdmmc.c py32f403_ll_spi.c py32f403_ll_tim.c py32f403_ll_usart.c py32f403_ll_utils.c
    ../../../BSP/PY32f403_Firmware_Library/CMSIS/Device/PUYA/PY32F403/Include/: py32f403xD.h
  group star
    ../../Application/Src/: startup_py32f403xx.s system_py32f403.c
