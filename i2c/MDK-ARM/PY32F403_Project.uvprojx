# Keil uVision project PY32F403_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PY32F403_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,PY32F403xD
  c include: ..\Firmware\CMSIS\Include;..\Firmware\PY32F403_HAL_Driver\Inc;..\Firmware\CMSIS\Device\PUYA\PY32F403\Include;..\Application\Inc;..\BSP\MCU_Driver\Inc;..\BSP\Module_Driver\QMI8658A;..\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../Application/Src/: main.c py32f403_hal_msp.c py32f403_it.c
    ../Application/Inc/: main.h py32f403_hal_conf.h
  group BSP/MCU_Driver
    ../BSP/MCU_Driver/Src/: i2c.c gpio.c usart.c tim.c
    ../BSP/MCU_Driver/Inc/: i2c.h gpio.h usart.h
  group BSP/Module_Driver
    ../BSP/Module_Driver/QMI8658A/: qmi8658a_driver.c qmi8658a_driver.h qmi8658a_reg.c qmi8658a_reg.h
  group Device
    ../Device/: gyro_device.h gyro_factory.h gyro_factory.c
  group Firmware
    ../Firmware/PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal_adc.c py32f403_hal_adc_ex.c py32f403_hal_canfd.c py32f403_hal_cortex.c py32f403_hal_crc.c py32f403_hal_ctc.c py32f403_hal_dma.c py32f403_hal_esmc.c py32f403_hal_exti.c py32f403_hal_flash.c py32f403_hal_gpio.c py32f403_hal_i2c.c py32f403_hal_i2s.c py32f403_hal_irda.c py32f403_hal_iwdg.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_rtc.c py32f403_hal_rtc_ex.c py32f403_hal_sd.c py32f403_hal_smartcard.c py32f403_hal_spi.c py32f403_hal_spi_ex.c py32f403_hal_tim.c py32f403_hal_tim_ex.c py32f403_hal_uart.c py32f403_hal_usart.c py32f403_hal_wwdg.c py32f403_ll_adc.c py32f403_ll_crc.c py32f403_ll_ctc.c py32f403_ll_dma.c py32f403_ll_exti.c py32f403_ll_gpio.c py32f403_ll_i2c.c py32f403_ll_pwr.c py32f403_ll_rcc.c py32f403_ll_rtc.c py32f403_ll_sdmmc.c py32f403_ll_spi.c py32f403_ll_tim.c py32f403_ll_usart.c py32f403_ll_utils.c
    ../Firmware/PY32F403_HAL_Driver/Inc/: py32f4xx_hal.h py32f403_hal_adc.h py32f403_hal_adc_ex.h py32f403_hal_canfd.h py32f403_hal_cortex.h py32f403_hal_crc.h py32f403_hal_ctc.h py32f403_hal_def.h py32f403_hal_dma.h py32f403_hal_dma_ex.h py32f403_hal_esmc.h py32f403_hal_exti.h py32f403_hal_flash.h py32f403_hal_gpio.h py32f403_hal_gpio_ex.h py32f403_hal_i2c.h py32f403_hal_i2s.h py32f403_hal_irda.h py32f403_hal_iwdg.h py32f403_hal_pwr.h py32f403_hal_pwr_ex.h py32f403_hal_rcc.h py32f403_hal_rcc_ex.h py32f403_hal_rtc.h py32f403_hal_rtc_ex.h py32f403_hal_sd.h py32f403_hal_smartcard.h py32f403_hal_spi.h py32f403_hal_spi_ex.h py32f403_hal_tim.h py32f403_hal_tim_ex.h py32f403_hal_uart.h py32f403_hal_usart.h py32f403_hal_wwdg.h py32f403_ll_adc.h py32f403_ll_bus.h py32f403_ll_cortex.h py32f403_ll_crc.h py32f403_ll_ctc.h py32f403_ll_dma.h py32f403_ll_exti.h py32f403_ll_flash.h py32f403_ll_gpio.h py32f403_ll_i2c.h py32f403_ll_iwdg.h py32f403_ll_pwr.h py32f403_ll_rcc.h py32f403_ll_rtc.h py32f403_ll_sdmmc.h py32f403_ll_spi.h py32f403_ll_system.h py32f403_ll_tim.h py32f403_ll_usart.h py32f403_ll_utils.h py32f403_ll_wwdg.h
  group star
    ../Application/Src/: startup_py32f403xx.s system_py32f403.c
