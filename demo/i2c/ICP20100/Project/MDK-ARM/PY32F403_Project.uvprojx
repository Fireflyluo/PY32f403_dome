# Keil uVision project PY32F403_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PY32F403_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,PY32F403xD
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\PY32F403_HAL_Driver\Inc;..\..\Libraries\CMSIS\Device\PUYA\PY32F403\Include;..\..\Application\Inc;..\..\BSP\MCU_Peripheral\Inc;..\..\BSP\Sensor_Driver\QMI8658A;..\..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Application/Src/: main.c py32f403_hal_msp.c py32f403_it.c
    ../../Application/Inc/: main.h py32f403_hal_conf.h py32f403_it.h
  group BSP/MCU_Peripheral
    ../../BSP/MCU_Peripheral/Src/: gpio.c usart.c i2c.c
  group BSP/Sensor_Driver
    ../../BSP/Sensor_Driver/QMI8658A/: qmi8658a_driver.c qmi8658a_driver.h qmi8658a_reg.c qmi8658a_reg.h
    ../../BSP/Sensor_Driver/ICP20100/: icp20100.c icp20100.h
  group Drivers
    ../../Drivers/: gyro_device.h gyro_factory.c gyro_factory.h
  group star
    ../../Application/Src/: system_py32f403.c startup_py32f403xx.s
  group Libraries
    ../../Libraries/PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal_adc.c py32f403_hal_adc_ex.c py32f403_hal_canfd.c py32f403_hal_cortex.c py32f403_hal_crc.c py32f403_hal_ctc.c py32f403_hal_dma.c py32f403_hal_esmc.c py32f403_hal_exti.c py32f403_hal_flash.c py32f403_hal_gpio.c py32f403_hal_i2c.c py32f403_hal_i2s.c py32f403_hal_irda.c py32f403_hal_iwdg.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_rtc.c py32f403_hal_rtc_ex.c py32f403_hal_sd.c py32f403_hal_smartcard.c py32f403_hal_spi.c py32f403_hal_spi_ex.c py32f403_hal_tim.c py32f403_hal_tim_ex.c py32f403_hal_uart.c py32f403_hal_usart.c py32f403_hal_wwdg.c py32f403_ll_adc.c py32f403_ll_crc.c py32f403_ll_ctc.c py32f403_ll_dma.c py32f403_ll_exti.c py32f403_ll_gpio.c py32f403_ll_i2c.c py32f403_ll_pwr.c py32f403_ll_rcc.c py32f403_ll_rtc.c py32f403_ll_sdmmc.c py32f403_ll_spi.c py32f403_ll_tim.c py32f403_ll_usart.c py32f403_ll_utils.c
