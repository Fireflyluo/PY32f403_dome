# Keil uVision project Project.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=4
  c define: USE_HAL_DRIVER,PY32F403xD
  c include: ..\firmware\PY32F403_HAL_Driver\Inc;..\firmware\CMSIS\Device\PUYA\PY32F403\Include;..\firmware\CMSIS\Include;..\firmware\BSP\PY32F403xx_Start_Kit;..\Application\Inc;..\Middleware;..\Public\RingBuffer;..\Public\mavlink;..\BSP\MCU_Driver\Src;..\BSP\MCU_Driver\Inc;..\BSP\Module_Driver\lcd;..\BSP\Module_Driver\SI24R1;..\BSP\Module_Driver\xl2400p;..\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../Application/Src/: main.c py32f403_it.c py32f403_hal_msp.c
    ../Application/Inc/: main.h py32f403_it.h py32f403_hal_conf.h
  group BSP/MCU_Driver
    ../BSP/MCU_Driver/Inc/: bsp_common.h bsp_core.h bsp_exti.h bsp_gpio.h bsp_uasrt.h bsp_spi.h LED.h bsp_tim.h bsp_pwm.h
    ../BSP/MCU_Driver/Src/: bsp_core.c bsp_gpio.c bsp_exti.c bsp_uasrt.c bsp_spi.c LED.c bsp_tim.c bsp_pwm.c
    ../../../SerialNet/Py32f403/Event_v1.0/BSP/MCU_Driver/Src/: tim.c
  group BSP/Module_Driver
    ../BSP/Module_Driver/SI24R1/: SI24R1.c SI24R1.h
    ../BSP/Module_Driver/lcd/: lcd.c lcd.h lcd_font.h
    ../BSP/Module_Driver/xl2400p/: xn297L.c xn297L.h
  group Device
    ../Device/: dev_common.h dev_led.c dev_led.h
  group Middleware
    ../Middleware/: serial.c serial.h
  group Public
    ../Public/RingBuffer/: kfifo.c kfifo.h
  group FWLIB
    ../firmware/PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal_adc.c py32f403_hal_adc_ex.c py32f403_hal_canfd.c py32f403_hal_cortex.c py32f403_hal_crc.c py32f403_hal_ctc.c py32f403_hal_dma.c py32f403_hal_esmc.c py32f403_hal_exti.c py32f403_hal_flash.c py32f403_hal_gpio.c py32f403_hal_i2c.c py32f403_hal_i2s.c py32f403_hal_irda.c py32f403_hal_iwdg.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_rtc.c py32f403_hal_rtc_ex.c py32f403_hal_sd.c py32f403_hal_smartcard.c py32f403_hal_spi.c py32f403_hal_spi_ex.c py32f403_hal_tim.c py32f403_hal_tim_ex.c py32f403_hal_uart.c py32f403_hal_usart.c py32f403_hal_wwdg.c
  group Doc
    ../: readme.md
software components: CMSIS:CORE 6.1.0, Device:Startup 0.0.6
